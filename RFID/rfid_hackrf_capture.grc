options:
  parameters:
    description: Captura RFID con HackRF (OsmoSDR)
    generate_options: qt_gui
    id: rfid_hackrf_capture
    output_language: python
    title: RFID HackRF Capture
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '16'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '24'
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: output_file
  id: variable
  parameters:
    value: '"rfid_capture_915M.cfile"'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: '""'
    args: '"numchan=1 hackrf=0"'
    bb_gain0: bb_gain
    bw0: bandwidth
    corr0: ppm
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    label: RFID Spectrum
    type: complex
    ymin: '-130'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_file
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
