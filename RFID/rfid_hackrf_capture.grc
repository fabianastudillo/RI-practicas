options:
  parameters:
    description: Captura RFID con HackRF (OsmoSDR)
    generate_options: qt_gui
    id: rfid_hackrf_capture
    output_language: python
    title: RFID HackRF Capture
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Freq (Hz)
    start: 10e6
    step: 1e5
    stop: 960e6
    value: 13.5e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '40'
    value: '16'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain (dB)
    start: '0'
    step: '1'
    stop: '47'
    value: '24'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB Gain (dB)
    start: '0'
    step: '1'
    stop: '62'
    value: '20'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: smooth_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: lpf_cutoff
  id: variable_qtgui_range
  parameters:
    label: LPF Cutoff (Hz)
    start: 10e3
    step: 5e3
    stop: 300e3
    value: 120e3
  states: {}
- name: env_gain
  id: variable_qtgui_range
  parameters:
    label: Env Gain
    start: '1.0'
    step: '1.0'
    stop: '200.0'
    value: '40.0'
  states: {}
- name: threshold_level
  id: variable_qtgui_range
  parameters:
    label: Threshold
    start: '0.01'
    step: '0.01'
    stop: '2.0'
    value: '0.35'
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: '""'
    args: '"numchan=1 hackrf=0"'
    bb_gain0: bb_gain
    bw0: bandwidth
    corr0: ppm
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,2
    label: RFID Spectrum
    type: complex
    ymin: '-130'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,2
    int_max: '-10'
    int_min: '-110'
    name: '"RFID Burst Waterfall"'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, lpf_cutoff, 20e3, window.WIN_HAMMING, 6.76)
    type: fff
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: smooth_len
    max_iter: '4096'
    scale: 1.0/smooth_len
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: env_gain
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshold_level*1.20
    init: '0'
    low: threshold_level
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: Envelope x Gain
    name: '"Pulse Viewer"'
    srate: samp_rate/decim
    size: '8192'
    type: float
    update_time: '0.02'
    width1: '2'
    ymax: '1.5'
    ymin: '-0.2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: red
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 3,2,1,2
    label1: Bits
    marker1: '1'
    name: '"Bitstream Viewer"'
    srate: samp_rate/decim
    size: '8192'
    style1: '2'
    type: float
    update_time: '0.02'
    width1: '3'
    ylabel: Logic
    ymax: '1.2'
    ymin: '-0.2'
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
