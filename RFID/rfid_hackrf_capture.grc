options:
  parameters:
    description: Captura RFID con HackRF (OsmoSDR)
    generate_options: qt_gui
    id: rfid_hackrf_capture
    output_language: python
    title: RFID HackRF Capture
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Freq (Hz)
    start: 10e6
    step: 1e5
    stop: 960e6
    value: 915e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '40'
    value: '16'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain (dB)
    start: '0'
    step: '1'
    stop: '47'
    value: '24'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB Gain (dB)
    start: '0'
    step: '1'
    stop: '62'
    value: '20'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: '""'
    args: '"numchan=1 hackrf=0"'
    bb_gain0: bb_gain
    bw0: bandwidth
    corr0: ppm
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,2
    label: RFID Spectrum
    type: complex
    ymin: '-130'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,2
    int_max: '-10'
    int_min: '-110'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
