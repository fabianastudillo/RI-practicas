options:
  parameters:
    description: Demo de lectura RFID con visualización y detección de UID en consola
    generate_options: qt_gui
    id: rfid_reader_demo
    output_language: python
    title: RFID Reader Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Freq (Hz)
    start: 10e6
    step: 1e5
    stop: 960e6
    value: 13.5e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '40'
    value: '16'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain (dB)
    start: '0'
    step: '1'
    stop: '47'
    value: '24'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB Gain (dB)
    start: '0'
    step: '1'
    stop: '62'
    value: '20'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: smooth_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: lpf_cutoff
  id: variable_qtgui_range
  parameters:
    label: LPF Cutoff (Hz)
    start: 10e3
    step: 5e3
    stop: 300e3
    value: 120e3
  states: {}
- name: env_gain
  id: variable_qtgui_range
  parameters:
    label: Env Gain
    start: '1.0'
    step: '1.0'
    stop: '200.0'
    value: '40.0'
  states: {}
- name: threshold_level
  id: variable_qtgui_range
  parameters:
    label: Threshold
    start: '0.01'
    step: '0.01'
    stop: '2.0'
    value: '0.35'
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: uid_repeats
  id: variable
  parameters:
    value: '3'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: '""'
    args: '"numchan=1 hackrf=0"'
    bb_gain0: bb_gain
    bw0: bandwidth
    corr0: ppm
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,2
    label: RFID Spectrum
    type: complex
    ymin: '-130'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,2
    int_max: '-10'
    int_min: '-110'
    name: '"RFID Burst Waterfall"'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, lpf_cutoff, 20e3, window.WIN_HAMMING, 6.76)
    type: fff
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: smooth_len
    max_iter: '4096'
    scale: 1.0/smooth_len
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: env_gain
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshold_level*1.20
    init: '0'
    low: threshold_level
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python block: detecta UID en stream binario y lo imprime.
      """

      import numpy as np
      from collections import defaultdict, deque
      from gnuradio import gr


      def bits_to_byte_lsb_first(bit_list):
          value = 0
          for i, b in enumerate(bit_list):
              value |= (int(b) & 0x1) << i
          return value


      class blk(gr.sync_block):
          """UID detector and passthrough"""

          def __init__(self, min_repeats=3):
              gr.sync_block.__init__(
                  self,
                  name='UID Detector',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8],
              )
              self.buffer = deque(maxlen=12000)
              self.min_repeats = int(min_repeats)
              self.counts = defaultdict(int)
              self.last_reported = None

          def _scan_candidates(self):
              bits = list(self.buffer)
              if len(bits) < 45:
                  return

              for offset in range(0, min(9, len(bits) - 44)):
                  frame = bits[offset:offset + 45]
                  groups = [frame[j * 9:(j + 1) * 9] for j in range(5)]
                  if any(len(group) != 9 for group in groups):
                      continue

                  data = [bits_to_byte_lsb_first(group[:8]) for group in groups]
                  bcc = data[0] ^ data[1] ^ data[2] ^ data[3]
                  if data[4] != bcc:
                      continue

                  uid = tuple(data[:4])
                  if all(v == 0x00 for v in uid):
                      continue

                  self.counts[uid] += 1
                  if self.counts[uid] >= self.min_repeats and uid != self.last_reported:
                      uid_hex = ''.join(f'{x:02X}' for x in uid)
                      print(f'[UID detectado] {uid_hex}')
                      self.last_reported = uid

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]

              out[:] = in0
              for x in in0:
                  self.buffer.append(1 if int(x) > 0 else 0)

              self._scan_candidates()
              return len(out)
    min_repeats: uid_repeats
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: Envelope x Gain
    name: '"Pulse Viewer"'
    srate: samp_rate/decim
    size: '8192'
    type: float
    update_time: '0.02'
    width1: '2'
    ymax: '1.5'
    ymin: '-0.2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: red
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 3,2,1,2
    label1: Bits
    marker1: '1'
    name: '"Bitstream Viewer"'
    srate: samp_rate/decim
    size: '8192'
    style1: '2'
    type: float
    update_time: '0.02'
    width1: '3'
    ylabel: Logic
    ymax: '1.2'
    ymin: '-0.2'
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_char_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
